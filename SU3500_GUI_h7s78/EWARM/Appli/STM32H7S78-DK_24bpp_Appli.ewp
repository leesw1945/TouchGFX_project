# IAR project STM32H7S78-DK_24bpp_Appli.ewp, settings and files
configuration STM32H7S78-DK_24bpp_Appli (ARM, debug)
  General.OGChipSelectEditMenu: STM32H7S78-DK ST STM32H7S78-DK
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H7S7xx; USE_BPP=32
  ICCARM.CCIncludePath2: ../../Appli/Core/Inc; ../../Appli/TouchGFX/App; ../../Appli/TouchGFX/target/generated; ../../Appli/TouchGFX/target; ../../Drivers/STM32H7xx_HAL_Driver/Inc; ../../Drivers/STM32H7RSxx_HAL_Driver/Inc; ../../Drivers/STM32H7RSxx_HAL_Driver/Inc/Legacy; ../../Middlewares/Third_Party/FreeRTOS/Source/include; ../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2; ../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../../Drivers/CMSIS/RTOS2/Include; ../../Drivers/CMSIS/Device/ST/STM32H7RSxx/Include; ../../Drivers/CMSIS/Include; ../../Drivers/STM32H7xx_HAL_Driver/Inc; ../../Drivers/STM32H7RSxx_HAL_Driver/Inc; ../../Drivers/STM32H7RSxx_HAL_Driver/Inc/Legacy; ../../Middlewares/Third_Party/FreeRTOS/Source/include; ../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2; ../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../../Drivers/CMSIS/RTOS2/Include; ../../Drivers/CMSIS/Device/ST/STM32H7RSxx/Include; ../../Drivers/CMSIS/Include; ../../Appli/Middlewares/ST/touchgfx/framework/include; ../../Appli/TouchGFX/generated/fonts/include; ../../Appli/TouchGFX/generated/images/include; ../../Appli/TouchGFX/generated/videos/include; ../../Appli/TouchGFX/generated/texts/include; ../../Appli/TouchGFX/generated/gui_generated/include; ../../Appli/TouchGFX/gui/include; ../../Appli/Middlewares/ST/touchgfx_components/gpu2d/NemaGFX/include; ../../Appli/Middlewares/ST/touchgfx_components/gpu2d/TouchGFXNema/include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ../../Appli/Core/Inc
  OBJCOPY.OOCOutputFile: STM32H7S78-DK_24bpp_Appli.hex
  ILINK.IlinkOutputFile: STM32H7S78-DK_24bpp_Appli.out
  ILINK.IlinkKeepSymbols: Bootloader
  ILINK.IlinkIcfFile: stm32h7rsxx_RAMxspi1_ROMxspi2.icf
  ILINK.IlinkAdditionalLibs: ../../Appli/Middlewares/ST/touchgfx/lib/core/cortex_m7/IAR9.x/touchgfx_core.a; ../../Appli/Middlewares/ST/touchgfx_components/gpu2d/NemaGFX/lib/core/cortex_m7/IAR8.x/nemagfx_core_release.a; ../../Appli/Middlewares/ST/touchgfx_components/gpu2d/TouchGFXNema/lib/cortex_m7/IAR8.x/touchgfx_nema_release.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../: startup_stm32h7s7xx.s
  group Application/User/Appli/Core
    ../../Appli/Core/Src/: main.c freertos.c stm32h7rsxx_it.c stm32h7rsxx_hal_msp.c stm32h7rsxx_hal_timebase_tim.c
  group Application/User/Appli/TouchGFX/App
    ../../Appli/TouchGFX/App/: app_touchgfx.c
  group Application/User/Appli/TouchGFX/target
    ../../Appli/TouchGFX/target/: CortexMMCUInstrumentation.cpp TouchGFXHAL.cpp STM32TouchController.cpp TouchGFXGPIO.cpp
  group Application/User/Appli/TouchGFX/target/generated
    ../../Appli/TouchGFX/target/generated/: TouchGFXConfiguration.cpp TouchGFXGeneratedHAL.cpp STM32DMA.cpp OSWrappers.cpp HardwareMJPEGDecoder.cpp nema_hal.c
  group Drivers/CMSIS
    ../../Appli/Core/Src/: system_stm32h7rsxx.c
  group Drivers/STM32H7RSxx_HAL_Driver
    ../../Drivers/STM32H7RSxx_HAL_Driver/Src/: stm32h7rsxx_hal_cortex.c stm32h7rsxx_hal_rcc.c stm32h7rsxx_hal_rcc_ex.c stm32h7rsxx_hal_flash.c stm32h7rsxx_hal_flash_ex.c stm32h7rsxx_hal_gpio.c stm32h7rsxx_hal_dma.c stm32h7rsxx_hal_dma_ex.c stm32h7rsxx_hal_pwr.c stm32h7rsxx_hal_pwr_ex.c stm32h7rsxx_hal.c stm32h7rsxx_hal_exti.c stm32h7rsxx_hal_tim.c stm32h7rsxx_hal_tim_ex.c stm32h7rsxx_hal_crc.c stm32h7rsxx_hal_crc_ex.c stm32h7rsxx_hal_dma2d.c stm32h7rsxx_hal_gfxmmu.c stm32h7rsxx_hal_gpu2d.c stm32h7rsxx_hal_i2c.c stm32h7rsxx_hal_i2c_ex.c stm32h7rsxx_hal_smbus.c stm32h7rsxx_hal_smbus_ex.c stm32h7rsxx_hal_icache.c stm32h7rsxx_hal_jpeg.c stm32h7rsxx_hal_ltdc.c stm32h7rsxx_hal_ltdc_ex.c
  group Middlewares/FreeRTOS
    ../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../../Middlewares/Third_Party/FreeRTOS/Source/portable/Common/: mpu_wrappers.c
    ../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
